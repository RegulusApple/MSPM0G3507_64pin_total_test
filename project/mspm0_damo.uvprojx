# Keil uVision project mspm0_damo.uvprojx, settings and files
target MSPM0G3507 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: adc12_max_freq_dma_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..;..\source\third_party\CMSIS\Core\Include;..\source\third_party\CMSIS\DSP\Include;..\source;..\usr\src;..\usr\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  group main
    ../: main.c mspm0_g3507.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group driverlib
    ../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../source/ti/driverlib/m0p/: dl_interrupt.c
    ../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group usr
    ../usr/src/: adc2chSample.c OLED.c soft_i2c.c signalProcess.c sysconfig.c uart_debug.c usr_uart.c key.c dac.c ad9833.c flash.c addr_code.c low_power.c serial_protocol.c gain_calibration.c signalProcess_ext.c analog_measure.c analog_calibration.c pid_controller.c wave_gen.c contest_selftest.c board_key_led_test.c ad9850.c freq_meter.c square_gen.c pwm_out.c psu_control.c menu.c usr_rtc.c usr_opa.c usr_comp.c
